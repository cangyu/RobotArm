# IAR project RobotArm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Application; ..\..\BSP; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\uC-CPU\Ports\ARM-Cortex-M3\IAR; ..\..\uC-CPU; ..\..\uC-LIB; ..\..\uCOS-II\Ports\ARM-Cortex-M\Generic\IAR; ..\..\uCOS-II\Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RobotArm.bin
  ILINK.IlinkOutputFile: RobotArm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\Application; ..\..\BSP; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\uC-CPU; ..\..\uC-CPU\Ports\ARM-Cortex-M3\IAR; ..\..\uC-LIB; ..\..\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\..\uCOS-II\Ports\ARM-Cortex-M\Generic\IAR; ..\..\uCOS-II\Source
  ICCARM.CCOptLevel: 3
  group APP
    ../../Application/: app.c stm32f10x_it.c
  group BSP
    ../../BSP/: RobotArmCtrlBoard.c Servo.c
  group LIB/CMSIS/DeviceSupport
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group LIB/STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group uC/OS-II/CPU/Port
    ../../uC-CPU/Ports/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
  group uC/OS-II/CPU/Src
    ../../uC-CPU/: cpu_core.c
  group uC/OS-II/LIB/Port
    ../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II/LIB/Src
    ../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-II/OS/Port
    ../../uCOS-II/Ports/ARM-Cortex-M/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-II/OS/Src
    ../../uCOS-II/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
